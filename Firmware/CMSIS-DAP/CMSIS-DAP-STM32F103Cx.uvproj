# Keil uVision project CMSIS-DAP-STM32F103Cx.uvproj, settings and files
target STM32F103-STLINK_V21 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F103-DAP-SWO-CDC-STLINK_V21 +hex
  AfterMake: ./Utilities/Binary/hex2bin.exe  ./build/F103-DAP-SWO-CDC-STLINK_V21.hex
  AfterMake: ./Utilities/Binary/hex2dfu.exe -t  ./build/F103-DAP-SWO-CDC-STLINK_V21.hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V21 SWO_PA10
  c include: .\CMSIS-DAP;.\USB;.\User;.\Driver\STM32F10x_ARM_Driver;.\Driver\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_conf.h system_stm32f10x.c startup_stm32f10x_md.s
  group CMSIS-DAP
    ./CMSIS-DAP/: DAP_config.h DAP.h DAP.c JTAG_DP.c SW_DP.c SWO.c
  group Driver
    ./Driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group USART
    ./Driver/STM32F10x_ARM_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c USART_STM32F10x.c
  group USB
    ./USB/: usb_config.c usbd_STM32F103.c usbd_user_hid.c usbd_user_cdc_acm.c USB_CM3.lib
target STM32F103-STLINK_V2B (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: as above
  output: F103-DAP-SWO-CDC-STLINK_V2B +hex
  AfterMake: ./Utilities/Binary/hex2bin.exe  ./build/F103-DAP-SWO-CDC-STLINK_V2B.hex
  AfterMake: ./Utilities/Binary/hex2dfu.exe -t ./build/F103-DAP-SWO-CDC-STLINK_V2B.hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V2B SWO_PA10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x5000
